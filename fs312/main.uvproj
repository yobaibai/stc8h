# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H4K64TL Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0FFF) IROM(0-0xFFF8) CLOCK(45000000) MODP2
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c EEPROM.c EEPROM.h config.h STC8xxxx.H intrins.h
